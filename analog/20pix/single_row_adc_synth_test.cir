Simulation of digital counter circuit synthesized with Yosys

** opencircuitdesign pdks install
.lib "/foss/pdk/sky130A/libs.tech/ngspice/sky130.lib.spice" tt
.include "/foss/pdk/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice"
.include single_row_adc_synth.model

* Instantiate the single_row_adc
XADC clk reset comp.0 comp.1 comp.2 comp.3 comp.4 comp.5 comp.6 comp.7 comp.8 comp.9 comp.10 comp.11 comp.12 comp.13 comp.14 comp.15 comp.16 comp.17 comp.18 comp.19 stored_values.0 stored_values.1 stored_values.2 stored_values.3 stored_values.4 stored_values.5 stored_values.6 stored_values.7 stored_values.8 stored_values.9 stored_values.10 stored_values.11 stored_values.12 stored_values.13 stored_values.14 stored_values.15 stored_values.16 stored_values.17 stored_values.18 stored_values.19 stored_values.20 stored_values.21 stored_values.22 stored_values.23 stored_values.24 stored_values.25 stored_values.26 stored_values.27 stored_values.28 stored_values.29 stored_values.30 stored_values.31 stored_values.32 stored_values.33 stored_values.34 stored_values.35 stored_values.36 stored_values.37 stored_values.38 stored_values.39 stored_values.40 stored_values.41 stored_values.42 stored_values.43 stored_values.44 stored_values.45 stored_values.46 stored_values.47 stored_values.48 stored_values.49 stored_values.50 stored_values.51 stored_values.52 stored_values.53 stored_values.54 stored_values.55 stored_values.56 stored_values.57 stored_values.58 stored_values.59 stored_values.60 stored_values.61 stored_values.62 stored_values.63 stored_values.64 stored_values.65 stored_values.66 stored_values.67 stored_values.68 stored_values.69 stored_values.70 stored_values.71 stored_values.72 stored_values.73 stored_values.74 stored_values.75 stored_values.76 stored_values.77 stored_values.78 stored_values.79 stored_values.80 stored_values.81 stored_values.82 stored_values.83 stored_values.84 stored_values.85 stored_values.86 stored_values.87 stored_values.88 stored_values.89 stored_values.90 stored_values.91 stored_values.92 stored_values.93 stored_values.94 stored_values.95 stored_values.96 stored_values.97 stored_values.98 stored_values.99 stored_values.100 stored_values.101 stored_values.102 stored_values.103 stored_values.104 stored_values.105 stored_values.106 stored_values.107 stored_values.108 stored_values.109 stored_values.110 stored_values.111 stored_values.112 stored_values.113 stored_values.114 stored_values.115 stored_values.116 stored_values.117 stored_values.118 stored_values.119 stored_values.120 stored_values.121 stored_values.122 stored_values.123 stored_values.124 stored_values.125 stored_values.126 stored_values.127 stored_values.128 stored_values.129 stored_values.130 stored_values.131 stored_values.132 stored_values.133 stored_values.134 stored_values.135 stored_values.136 stored_values.137 stored_values.138 stored_values.139 stored_values.140 stored_values.141 stored_values.142 stored_values.143 stored_values.144 stored_values.145 stored_values.146 stored_values.147 stored_values.148 stored_values.149 stored_values.150 stored_values.151 stored_values.152 stored_values.153 stored_values.154 stored_values.155 stored_values.156 stored_values.157 stored_values.158 stored_values.159 vss vss vdd vdd single_row_adc

* Voltage sources
.param vdd=1.8
Vvdd vdd 0 {vdd}

.param vss=0
Vvss vss 0 {vss}

** Clock and Reset signals (1MHz clock)
Vrst    reset   0   pulse   {vdd}   {vss}   2u      10n  10n  490u    500u
Vclk    clk     0   pulse   {vss}   {vdd}   200n    10n  10n  0.5u     1u

* Comparator signal (example: 5 comparators with random outputs)
* Here, we simulate random '1's and '0's for comparators, adjust as needed
Vcomp0 comp.0 0 pulse {vdd} {vss} 0 5n 5n 5u 259u
Vcomp1 comp.1 0 pulse {vdd} {vss} 0 5n 5n 10u 259u
Vcomp2 comp.2 0 pulse {vdd} {vss} 0 5n 5n 15u 259u
Vcomp3 comp.3 0 pulse {vdd} {vss} 0 5n 5n 20u 259u
Vcomp4 comp.4 0 pulse {vdd} {vss} 0 5n 5n 25u 259u
Vcomp5 comp.5 0 pulse {vdd} {vss} 0 5n 5n 30u 259u
Vcomp6 comp.6 0 pulse {vdd} {vss} 0 5n 5n 35u 259u
Vcomp7 comp.7 0 pulse {vdd} {vss} 0 5n 5n 40u 259u
Vcomp8 comp.8 0 pulse {vdd} {vss} 0 5n 5n 45u 259u
Vcomp9 comp.9 0 pulse {vdd} {vss} 0 5n 5n 50u 259u
Vcomp10 comp.10 0 pulse {vdd} {vss} 0 5n 5n 55u 259u
Vcomp11 comp.11 0 pulse {vdd} {vss} 0 5n 5n 60u 259u
Vcomp12 comp.12 0 pulse {vdd} {vss} 0 5n 5n 65u 259u
Vcomp13 comp.13 0 pulse {vdd} {vss} 0 5n 5n 70u 259u
Vcomp14 comp.14 0 pulse {vdd} {vss} 0 5n 5n 75u 259u
Vcomp15 comp.15 0 pulse {vdd} {vss} 0 5n 5n 80u 259u
Vcomp16 comp.16 0 pulse {vdd} {vss} 0 5n 5n 85u 259u
Vcomp17 comp.17 0 pulse {vdd} {vss} 0 5n 5n 90u 259u
Vcomp18 comp.18 0 pulse {vdd} {vss} 0 5n 5n 95u 259u
Vcomp19 comp.19 0 pulse {vdd} {vss} 0 5n 5n 100u 259u

** Simulation settings
.control
option KLU
** option rshunt = 1.0e10
** option cshunt = 1.3e-13
tran 10n 30u
** rshunt=1G cshunt=0.1p *chgtol=1e-11 reltol=0.01 rshunt=1G rseries=0.05 cshunt=1p trtol=1
** .save i(Vvdd) v(clk) v(reset) v(comp.0) v(stored_values.0) v(stored_values.1) v(stored_values.2) v(stored_values.3) v(stored_values.4) v(stored_values.5) v(stored_values.6) v(stored_values.7)
** v(comp.1) v(comp.2) v(comp.3) v(comp.4) v(stored_values.8) v(stored_values.9) v(stored_values.10) v(stored_values.11) v(stored_values.12) v(stored_values.13) v(stored_values.14) v(stored_values.15) v(stored_values.16) v(stored_values.17) v(stored_values.18) v(stored_values.19) v(stored_values.20) v(stored_values.21) v(stored_values.22) v(stored_values.23) v(stored_values.24) v(stored_values.25) v(stored_values.26) v(stored_values.27) v(stored_values.28) v(stored_values.29) v(stored_values.30) v(stored_values.31) v(stored_values.32) v(stored_values.33) v(stored_values.34) v(stored_values.35) v(stored_values.36) v(stored_values.37) v(stored_values.38) v(stored_values.39)

plot v(clk) 2+v(reset) 4+v(comp.0) 6+v(comp.1) 8+v(comp.2) 10+v(comp.3) 12+v(comp.4)
plot v(stored_values.0) 2+v(stored_values.1) 4+v(stored_values.2) 6+v(stored_values.3) 8+v(stored_values.4) 10+v(stored_values.5) 12+v(stored_values.6) 14+v(stored_values.7)
plot v(stored_values.8) 2+v(stored_values.9) 4+v(stored_values.10) 6+v(stored_values.11) 8+v(stored_values.12) 10+v(stored_values.13) 12+v(stored_values.14) 14+v(stored_values.15)
plot v(stored_values.16) 2+v(stored_values.17) 4+v(stored_values.18) 6+v(stored_values.19) 8+v(stored_values.20) 10+v(stored_values.21) 12+v(stored_values.22) 14+v(stored_values.23)
plot v(stored_values.24) 2+v(stored_values.25) 4+v(stored_values.26) 6+v(stored_values.27) 8+v(stored_values.28) 10+v(stored_values.29) 12+v(stored_values.30) 14+v(stored_values.31)
*plot v(stored_values.32) 2+v(stored_values.33) 4+v(stored_values.34) 6+v(stored_values.35) 8+v(stored_values.36) 10+v(stored_values.37) 12+v(stored_values.38) 14+v(stored_values.39)
.endc

.END
