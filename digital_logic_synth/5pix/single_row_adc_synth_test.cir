Simulation of digital counter circuit synthesized with Yosys

** opencircuitdesign pdks install
.lib "/foss/pdk/sky130A/libs.tech/ngspice/sky130.lib.spice" tt
.include "/foss/pdk/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice"
.include single_row_adc_synth.model

* Instantiate the single_row_adc
XADC clk reset comp.0 comp.1 comp.2 comp.3 comp.4 stored_values.0 stored_values.1 stored_values.2 stored_values.3 stored_values.4 stored_values.5 stored_values.6 stored_values.7 stored_values.8 stored_values.9 stored_values.10 stored_values.11 stored_values.12 stored_values.13 stored_values.14 stored_values.15 stored_values.16 stored_values.17 stored_values.18 stored_values.19 stored_values.20 stored_values.21 stored_values.22 stored_values.23 stored_values.24 stored_values.25 stored_values.26 stored_values.27 stored_values.28 stored_values.29 stored_values.30 stored_values.31 stored_values.32 stored_values.33 stored_values.34 stored_values.35 stored_values.36 stored_values.37 stored_values.38 stored_values.39 vss vss vdd vdd single_row_adc

* Voltage sources
.param vdd=1.8
Vvdd vdd 0 {vdd}

.param vss=0
Vvss vss 0 {vss}

** Clock and Reset signals (1MHz clock)
Vrst    reset   0   pulse   {vdd}   {vss}   3u      10n  10n  490u    500u
Vclk    clk     0   pulse   {vss}   {vdd}   200n    10n  10n  0.5u      1u

* Comparator signal (example: 5 comparators with random outputs)
* Here, we simulate random '1's and '0's for comparators, adjust as needed
Vcomp0 comp.0 0 pulse {vdd} {vss} 0 5n 5n 60u  256u
Vcomp1 comp.1 0 pulse {vdd} {vss} 0 5n 5n 160u 256u
Vcomp2 comp.2 0 pulse {vdd} {vss} 0 5n 5n 32u  256u
Vcomp3 comp.3 0 pulse {vdd} {vss} 0 5n 5n 19u  256u
Vcomp4 comp.4 0 pulse {vdd} {vss} 0 5n 5n 5u  256u

** Simulation settings
.control
option KLU
tran 10n 259u
*save i(Vvdd) v(clk) v(reset) v(comp.0) v(comp.1) v(comp.2) v(comp.3) v(comp.4) v(stored_values.0) v(stored_values.1) v(stored_values.2) v(stored_values.3) v(stored_values.4) v(stored_values.5) v(stored_values.6) v(stored_values.7) v(stored_values.8) v(stored_values.9) v(stored_values.10) v(stored_values.11) v(stored_values.12) v(stored_values.13) v(stored_values.14) v(stored_values.15) v(stored_values.16) v(stored_values.17) v(stored_values.18) v(stored_values.19) v(stored_values.20) v(stored_values.21) v(stored_values.22) v(stored_values.23) v(stored_values.24) v(stored_values.25) v(stored_values.26) v(stored_values.27) v(stored_values.28) v(stored_values.29) v(stored_values.30) v(stored_values.31) v(stored_values.32) v(stored_values.33) v(stored_values.34) v(stored_values.35) v(stored_values.36) v(stored_values.37) v(stored_values.38) v(stored_values.39) i(vdd)

*plot v(clk) 2+v(reset) 4+v(comp.0) 6+v(comp.1) 8+v(comp.2) 10+v(comp.3) 12+v(comp.4)
*plot v(stored_values.0) 2+v(stored_values.1) 4+v(stored_values.2) 6+v(stored_values.3) 8+v(stored_values.4) 10+v(stored_values.5) 12+v(stored_values.6) 14+v(stored_values.7)
*plot v(stored_values.8) 2+v(stored_values.9) 4+v(stored_values.10) 6+v(stored_values.11) 8+v(stored_values.12) 10+v(stored_values.13) 12+v(stored_values.14) 14+v(stored_values.15)
*plot v(stored_values.16) 2+v(stored_values.17) 4+v(stored_values.18) 6+v(stored_values.19) 8+v(stored_values.20) 10+v(stored_values.21) 12+v(stored_values.22) 14+v(stored_values.23)
*plot v(stored_values.24) 2+v(stored_values.25) 4+v(stored_values.26) 6+v(stored_values.27) 8+v(stored_values.28) 10+v(stored_values.29) 12+v(stored_values.30) 14+v(stored_values.31)
*plot v(stored_values.32) 2+v(stored_values.33) 4+v(stored_values.34) 6+v(stored_values.35) 8+v(stored_values.36) 10+v(stored_values.37) 12+v(stored_values.38) 14+v(stored_values.39)
.endc

.END
