Simulation of digital counter circuit synthesized with Yosys

** opencircuitdesign pdks install
.lib "/foss/pdk/sky130A/libs.tech/ngspice/sky130.lib.spice" tt
.include "/foss/pdk/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice"
.include counter_synth.model

XCOUNTER Clk Rst Cnt_en Cnt.7 Cnt.6 Cnt.5 Cnt.4 Cnt.3 Cnt.2 Cnt.1 Cnt.0 vss vss vdd vdd counter
** XCOUNTER Clk Rst Cnt_en Cnt.2 Cnt.1 Cnt.0 vss vss vdd vdd counter

.param vdd=1.8
Vvdd vdd 0 {vdd}

.param vss=0
Vvss vss 0 {vss}

Vrst Rst 0 pulse {vdd} 500n 0 5n 5n 390u 400u
Vclk Clk 0 pulse 0 {vdd} 200n 5n 5n 1u 2u
Vcnt_en Cnt_en 0 pulse 0 {vdd} 3u 5n 5n 95u 110u

.control
tran 100n 500u 0 1n
plot v(Clk) 2+v(Rst) 4+v(Cnt_en) 6+v(Cnt.0) 8+v(Cnt.1) 10+v(Cnt.2) 12+v(Cnt.3) 14+v(Cnt.4) 16+v(Cnt.5) 18+v(Cnt.6) 20+v(Cnt.7)
.endc

.ENDC
.END
